FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI += "\
    file://bug30271.patch \
"
